# Keil uVision project TL2_6.uvproj, settings and files
target TL2_6 (MCS-51)
  device: SC92L7533 SC92Lxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0xEFF) CLOCK(32000000)
  output: TL2_6 +hex
  c flags: Optimize=8
  c define: SC92L753x
  c include: ..\FWLib\SC92F_Lib\inc;..\User;..\User\inc;..\Hardware;..\Apps;..\Wifi\mcu_sdk;..\Hardware;..\PWR
  link misc: REMOVEUNUSED
  group User
    ../User/: main.c SC_Init.c SC_it.c SysFunVarDefine.c CompCtrlDefine.c CallBackFunction.c
    ../User/src/: app_fsm.c
  group Drivers
    ../Drivers/: SCDriver_List.h
  group FWLib
    ../FWLib/SC92F_Lib/src/: sc92f_gpio.c sc92f_option.c sc92f_int.c sc92f_usci2.c sc92f_adc.c putchar.c sc92f_acmp.c sc92f_btm.c sc92f_chksum.c sc92f_crc.c sc92f_ddic.c sc92f_iap.c sc92f_lpd.c sc92f_mdu.c sc92f_pwm.c sc92f_pwr.c sc92f_ssi.c sc92f_ssi0.c sc92f_ssi1.c sc92f_timer0.c sc92f_timer1.c sc92f_timer2.c sc92f_timer3.c sc92f_timer4.c sc92f_uart0.c sc92f_uart2.c sc92f_uart3.c sc92f_usci0.c sc92f_usci1.c sc92f_wdt.c sc92f_zoc.c SC92F5x5x_IAP_L_lib_V1.1.3.LIB SC92F5x5x_IAP_S_lib_V1.1.3.LIB SC92F6x1x_CRC_L_lib_V1.0.0.LIB SC92F6x1x_CRC_S_lib_V1.0.0.LIB SC92F6x1x_IAP_L_lib_V1.1.2.LIB SC92F6x1x_IAP_S_lib_V1.1.2.LIB SC92F531x_IAP_L_lib_V1.1.3.LIB SC92F531x_IAP_S_lib_V1.1.3.LIB SC92F531x_ZCD_L_lib_V1.0.LIB SC92F531x_ZCD_S_lib_V1.0.LIB SC92F552X_CRC_L_lib_V1.0.0.LIB SC92F552X_CRC_S_lib_V1.0.0.LIB SC92F552x_IAP_L_lib_V1.1.3.LIB SC92F552x_IAP_S_lib_V1.1.3.LIB SC92F637x_IAP_L_lib_V1.1.3.LIB SC92F637x_IAP_S_lib_V1.1.3.LIB SC92F652X_CRC_L_lib_V1.0.0.LIB SC92F652X_CRC_S_lib_V1.0.0.LIB SC92F652x_IAP_L_lib_V1.1.2.LIB SC92F652x_IAP_S_lib_V1.1.2.LIB SC92F663x_CRC_L_lib_V1.0.1.LIB SC92F663x_CRC_S_lib_V1.0.1.LIB SC92F663x_IAP_L_lib_V1.1.4.LIB SC92F663x_IAP_S_lib_V1.1.4.LIB SC92Fx41xB_IAP_L_lib_V1.1.2.LIB SC92Fx41xB_IAP_S_lib_V1.1.2.LIB SC92L840x_CRC_L_lib_V1.0.0.LIB SC92L840x_CRC_S_lib_V1.0.0.LIB SC92L840x_IAP_L_lib_V1.1.2.LIB SC92L840x_IAP_S_lib_V1.1.2.LIB SC92L840x_STOP_L_lib_V1.0.0.LIB SC92R436_CRC_L_lib_V1.0.0.LIB SC92L840x_STOP_S_lib_V1.0.0.LIB SC92R51x_R52x_CRC_L_lib_V1.0.0.LIB SC92R51x_R52x_CRC_S_lib_V1.0.0.LIB SC92R51x_R52x_IAP_L_lib_V1.1.3.LIB SC92R51x_R52x_IAP_S_lib_V1.1.3.LIB SC92R422A_CRC_L_lib_V1.0.0.LIB SC92R422A_CRC_S_lib_V1.0.0.LIB SC92R422A_IAP_L_lib_V1.1.2.LIB SC92R422A_IAP_S_lib_V1.1.2.LIB SC92R436_CRC_S_lib_V1.0.0.LIB SC92R436_IAP_L_lib_V1.1.2.LIB SC92R436_IAP_S_lib_V1.1.2.LIB SC92R438_CRC_L_lib_V1.0.0.LIB SC92R438_CRC_S_lib_V1.0.0.LIB SC92R438_IAP_L_lib_V1.1.2.LIB SC92R438_IAP_S_lib_V1.1.2.LIB SC92R439_CRC_L_lib_V1.0.0.LIB SC92R439_CRC_S_lib_V1.0.0.LIB SC92R439_IAP_L_lib_V1.1.2.LIB SC92R439_IAP_S_lib_V1.1.2.LIB SC92R445_IAP_L_lib_V1.1.2.LIB SC92R445_IAP_S_lib_V1.1.2.LIB
  group Startup
    ./: STARTUP.A51
  group Hardware
    ../Hardware/: hal_adc.c hal_buzzer.c hal_ir.c hal_pwm.c hal_tm1650.c hal_touch.c hal_uart.c hal_eeprom.c hal_lpd.c
  group Wifi
    ../Wifi/mcu_sdk/: mcu_api.c mcu_api.h offline_voice_word_zh_cn.h protocol.c protocol.h readme.txt system.c system.h tuya_type.h wifi.h
  group PWR
    ../PWR/: sc89601.c app_wifi.c hal_power.c
